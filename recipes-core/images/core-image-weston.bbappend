IMAGE_INSTALL_append = " \
    iproute2 \
    libsocketcan \
    canutils \
    mmc-utils \
    tslib \
"

